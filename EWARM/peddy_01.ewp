# IAR project peddy_01.ewp, settings and files
configuration peddy_01 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F302VE ST STM32F302VE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F302xE
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F3xx_HAL_Driver/Inc; ../Drivers/STM32F3xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F3xx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: peddy_01.hex
  ILINK.IlinkOutputFile: peddy_01.out
  ILINK.IlinkIcfFile: stm32f302xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f302xe.s
  group Application/inc
    ../Inc/: adc.h dma.h gpio.h i2c.h main.h stm32f3xx_hal_conf.h stm32f3xx_it.h sys_adc.h sys_gpio.h sys_H_T_sensor.h sys_motor.h sys_timerutil.h sys_ultra.h tim.h usart.h
  group Application/User
    ../Src/: sys_gpio.c sys_H_T_sensor.c sys_motor.c sys_timerutil.c sys_ultra.c main.c gpio.c adc.c dma.c i2c.c tim.c usart.c stm32f3xx_it.c stm32f3xx_hal_msp.c
  group Drivers/CMSIS
    ../Src/: system_stm32f3xx.c
  group Drivers/STM32F3xx_HAL_Driver
    ../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal_adc.c stm32f3xx_hal_adc_ex.c stm32f3xx_hal.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_dma.c stm32f3xx_hal_cortex.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_flash.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_i2c.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_exti.c stm32f3xx_hal_tim.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_uart.c stm32f3xx_hal_uart_ex.c
